# IAR project dualcanbus3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105R8 ST STM32F105R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F105xC; USE_STDPERIPH_DRIVER; USER_VECT_TAB_ADDRESS
  ICCARM.CCIncludePath2: C:\Users\esllab\Documents\8.dualcanbus3; C:\Users\esllab\Documents\8.dualcanbus3\Debug\Obj\Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dualcanbus3.srec
  ILINK.IlinkOutputFile: dualcanbus3.out
  ILINK.IlinkIcfFile: C:\Users\esllab\Documents\8.dualcanbus3\dualcanbus3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Driver
    ./: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h mpu_armv7.h startup_stm32f105xc.s stm32f105xc.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group header
    ./: CANconfig.h GlobalVariable.h GPIOconfig.h NVICconfig.h SystemClockConfig.h TimerConfig.h
  group source
    ./: CANconfig.c GPIOconfig.c NVICconfig.c SystemClockConfig.c TimerConfig.c
